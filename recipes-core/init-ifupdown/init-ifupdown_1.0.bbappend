#Adiciona o patch no path de arquivos da receita
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
